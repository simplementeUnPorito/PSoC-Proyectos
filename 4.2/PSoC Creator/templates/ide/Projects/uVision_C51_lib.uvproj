# Keil uVision project uVision_C51_lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: Ex1_LED_with_PWM_lib (library)
  c flags: Optimize=8 SizeSpeed=1
  c misc: NOIV
  group Source Files
    ./: 
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: Ex1_LED_with_PWM_lib (library)
  c flags: Optimize=8 SizeSpeed=1
  c misc: NOIV
