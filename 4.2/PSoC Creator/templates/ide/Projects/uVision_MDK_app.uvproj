# Keil uVision project uVision_MDK_app.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ProjectName +hex
  AfterMake: ProjectName.bat
  c flags: Optim=1 OneElfS=1
  c misc: --diag_suppress=957 --diag_style=gnu --device=DLM
  c include: ..\ProjectName.cydsn;..\ProjectName.cydsn\Generated_Source\PSoC5
  asm misc: --diag_style=gnu --thumb --device=DLM
  asm include: as above
  link misc: --diag_style=gnu --device=DLM
  group Firmware
    ./: 
  group Start
    ./: 
  group DebugLib
    ./: 
  group ReleaseLib
    ./: 
target Release (ARM-ADS)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ProjectName +hex
  AfterMake: ProjectName.bat
  c flags: Optim=1 OneElfS=1
  c misc: --diag_suppress=957 --diag_style=gnu --list
  c include: as above
  asm misc: --diag_style=gnu --thumb
  asm include: as above
  link misc: --diag_style=gnu
