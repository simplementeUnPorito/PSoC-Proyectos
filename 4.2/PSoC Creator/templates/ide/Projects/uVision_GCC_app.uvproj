# Keil uVision project uVision_GCC_app.uvproj, settings and files
target Debug (ARM-GNU)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ProjectName +hex
  AfterMake: cyHextool.bat
  group Firmware
    ./: 
  group Start
    ./: 
  group DebugLib
    ./: 
  group ReleaseLib
    ./: 
target Release (ARM-GNU)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ProjectName +hex
  AfterMake: cyHextool.bat
