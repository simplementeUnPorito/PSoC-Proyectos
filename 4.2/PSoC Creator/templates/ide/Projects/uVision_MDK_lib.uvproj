# Keil uVision project uVision_MDK_lib.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ProjectName (library)
  c flags: Optim=1 OneElfS=1
  c misc: --diag_suppress=951 --diag_style=gnu --device=DLM
  c include: ..\ProjectName.cydsn;..\ProjectName.cydsn\Generated_Source\PSoC5
  asm misc: --diag_style=gnu --thumb --device=DLM
  asm include: as above
  scatter file: ..\ProjectName.cydsn\Generated_Source\PSoC5\Cm3RealView.scat
  link misc: --diag_style=gnu --no_startup --device=DLM
  group Source Files
    ./: 
target Release (ARM-ADS)
  device: Cortex-M3 Cypress
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ProjectName (library)
  c flags: Optim=1 OneElfS=1
  c misc: --diag_suppress=951 --diag_style=gnu --device=DLM
  c include: as above
  asm misc: --diag_style=gnu --thumb --device=DLM
  asm include: as above
  scatter file: ..\ProjectName.cydsn\Generated_Source\PSoC5\Cm3RealView.scat
  link misc: --diag_style=gnu --no_startup --device=DLM
